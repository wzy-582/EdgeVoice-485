# Keil uVision project EdgeVoice485.uvprojx, settings and files
target STM32F103ZE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EdgeVoice_485 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Inc;..\Application\Inc;..\Services\Inc;..\..\..\Utilities\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32F10x\Include;..\..\..\Drivers\STM32F10x_StdPeriph_Driver\inc;..\..\..\Drivers\BSP\EdgeVoice485_Board\Inc;..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Src/: startup_stm32f10x_hd.s
  group CMSIS
    ../../../Drivers/CMSIS/Include/: core_cm3.c
    ../Src/: system_stm32f10x.c
  group StdPeriph
    ../../../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group BSP
    ../../../Drivers/BSP/EdgeVoice485_Board/Src/: bsp.c bsp_clock.c bsp_led.c
  group Project_Core
    ../Src/: main.c stm32f10x_it.c freertos_hooks.c
  group Application
    ../Application/Src/: app.c app_tasks.c task_system.c
